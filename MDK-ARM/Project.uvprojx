# Keil uVision project Project.uvprojx, settings and files
target Player (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: buildout
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__FPU_USED,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM
  c include: ..\Inc;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Hardware\usart;..\Hardware\sys;..\Hardware\spi;..\Hardware\sd;..\Hardware\flash;..\Fatfs;..\Hardware\led;..\Hardware\i2c;..\Hardware\i2s;..\Hardware\uda1380;..\Hardware\dma;..\Dsplib\Include;..\Dsplib;..\Hardware\adc;..\Hardware\i2s_dac;..\Hardware\voltage_trans;..\Hardware\i2s_adc;..\Hardware\phantompower;..\Hardware\ext_osc;..\U8glib\inc;..\Hardware\sdio;..\Hardware\amp;..\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group MDK-ARM
    ./: startup_stm32f407xx.s
  group User
    ../Src/: stm32f4xx_it.c main.c file.c wav.c dsp.c system_stm32f4xx.c usb_device.c usbd_audio_if.c usbd_conf.c usbd_desc.c bsp_audio.c stm32f4xx_hal_msp.c
  group Hardware
    ../Hardware/usart/: usart.c
    ../Hardware/sys/: sys.c
    ../Hardware/spi/: spi.c
    ../Hardware/sd/: mmc_sd.c
    ../Hardware/flash/: flash.c
    ../Hardware/led/: led.c
    ../Hardware/i2c/: i2c.c
    ../Hardware/i2s/: i2s.c
    ../Hardware/uda1380/: uda1380.c
    ../Hardware/dma/: dma.c
    ../Hardware/adc/: adc.c
    ../Hardware/i2s_dac/: i2s_dac.c
    ../Hardware/voltage_trans/: vt.c
    ../Hardware/i2s_adc/: i2s_adc.c
    ../Hardware/phantompower/: phantompowers.c
    ../Hardware/ext_osc/: ext_osc.c
    ../Hardware/sdio/: sdio.c
    ../Hardware/amp/: amp.c
  group Fatfs
    ../Fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
  group Dsplib
    ../Dsplib/: arm_cortexM4lf_math.lib
    ../Dsplib/Include/: arm_math.h
  group U8glib
    ../U8glib/src/: u8g_arm.c u8g_bitmap.c u8g_circle.c u8g_clip.c u8g_com_api.c u8g_com_api_16gr.c u8g_com_i2c.c u8g_com_io.c u8g_com_null.c u8g_com_std_sw_spi.c u8g_cursor.c u8g_delay.c u8g_dev_ssd1306_128x64.c u8g_ellipse.c u8g_font.c u8g_font_data.c u8g_line.c u8g_ll_api.c u8g_page.c u8g_pb.c u8g_pb8h1.c u8g_pb8h1f.c u8g_pb8h2.c u8g_pb8h8.c u8g_pb8v1.c u8g_pb8v2.c u8g_pb14v1.c u8g_pb16h1.c u8g_pb16h2.c u8g_pb16v1.c u8g_pb16v2.c u8g_pb32h1.c u8g_pbxh16.c u8g_pbxh24.c u8g_polygon.c u8g_rect.c u8g_scale.c u8g_state.c u8g_u8toa.c u8g_u16toa.c u8g_virtual_screen.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
software components: CMSIS:CORE 5.0.1
